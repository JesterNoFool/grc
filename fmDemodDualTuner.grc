options:
  parameters:
    author: Gary Schafer
    generate_options: qt_gui
    id: fmDemodDualTuner
    output_language: python
    title: FM Demod with Dual Receivers
  states: {}

blocks:
- name: freq01
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,10
    label: 'Frequency Offset #1 (kHz)'
    start: '-samp_rate/2000'
    step: '25'
    stop: samp_rate/2000
    value: '0'
  states: {}
- name: freq02
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,10,1,10
    label: 'Frequency Offset #2 (kHz)'
    start: '-samp_rate/2000'
    step: '25'
    stop: samp_rate/2000
    value: '0'
  states: {}
- name: hwFreq
  id: variable_qtgui_label
  parameters:
    gui_hint: 0,0,1,10
    label: 'HW Frequency (MHz): '
    type: real
    value: '162.3'
  states: {}
- name: lpf
  id: variable
  parameters:
    value: firdes.low_pass(1,samp_rate,7.5e3,7.5e3,5)
  states: {}
- name: rfGain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,10,1,10
    label: RF Gain (dB)
    start: '0'
    step: '1'
    stop: '50'
    value: '16'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.4e6
  states: {}
- name: volume01
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,0,1,10
    label: Volume (Left Ear, dB)
    start: '-100'
    step: '0.1'
    stop: '20'
    value: '-30'
  states: {}
- name: volume02
  id: variable_qtgui_range
  parameters:
    gui_hint: 2,10,1,10
    label: Volume (Right Ear, dB)
    start: '-100'
    step: '0.1'
    stop: '20'
    value: '-30'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate/10/(2*np.pi*15e3)
  states: {}
- name: analog_quadrature_demod_cf_0_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate/10/(2*np.pi*15e3)
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    num_inputs: '2'
    samp_rate: '48000'
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: '10'
    type: complex
  states: {}
- name: blocks_keep_one_in_n_0_0
  id: blocks_keep_one_in_n
  parameters:
    n: '10'
    type: complex
  states: {}
- name: filter_fft_low_pass_filter_0
  id: filter_fft_low_pass_filter
  parameters:
    cutoff_freq: 10e3
    decim: '5'
    gain: 10**(volume01/20)
    samp_rate: samp_rate/10
    type: fff
    width: 4e3
    win: window.WIN_HAMMING
  states: {}
- name: filter_fft_low_pass_filter_0_0
  id: filter_fft_low_pass_filter
  parameters:
    cutoff_freq: 10e3
    decim: '5'
    gain: 10**(volume02/20)
    samp_rate: samp_rate/10
    type: fff
    width: 4e3
    win: window.WIN_HAMMING
  states: {}
- name: freq_xlating_fft_filter_ccc_0
  id: freq_xlating_fft_filter_ccc
  parameters:
    center_freq: freq02*1000
    decim: '1'
    samp_rate: samp_rate
    taps: lpf
  states: {}
- name: freq_xlating_fft_filter_ccc_0_0
  id: freq_xlating_fft_filter_ccc
  parameters:
    center_freq: freq01*1000
    decim: '1'
    samp_rate: samp_rate
    taps: lpf
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '8192'
    grid: 'True'
    gui_hint: 3,0,20,20
    label1: Left Ear
    label2: Right Ear
    label3: Full Spectrum
    nconnections: '3'
    type: complex
    ymax: '0'
    ymin: '-120'
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: hwFreq*1e6
    gain0: rfGain
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', filter_fft_low_pass_filter_0, '0']
- [analog_quadrature_demod_cf_0_0, '0', filter_fft_low_pass_filter_0_0, '0']
- [blocks_keep_one_in_n_0, '0', analog_quadrature_demod_cf_0_0, '0']
- [blocks_keep_one_in_n_0_0, '0', analog_quadrature_demod_cf_0, '0']
- [filter_fft_low_pass_filter_0, '0', audio_sink_0, '0']
- [filter_fft_low_pass_filter_0_0, '0', audio_sink_0, '1']
- [freq_xlating_fft_filter_ccc_0, '0', blocks_keep_one_in_n_0, '0']
- [freq_xlating_fft_filter_ccc_0, '0', qtgui_freq_sink_x_0, '1']
- [freq_xlating_fft_filter_ccc_0_0, '0', blocks_keep_one_in_n_0_0, '0']
- [freq_xlating_fft_filter_ccc_0_0, '0', qtgui_freq_sink_x_0, '0']
- [rtlsdr_source_0, '0', freq_xlating_fft_filter_ccc_0, '0']
- [rtlsdr_source_0, '0', freq_xlating_fft_filter_ccc_0_0, '0']
- [rtlsdr_source_0, '0', qtgui_freq_sink_x_0, '2']

metadata:
  file_format: 1
