options:
  parameters:
    author: Gary Schafer
    generate_options: qt_gui
    id: fmDemodNoTuning
    output_language: python
    title: FM Demodulation without Tuning
  states: {}

blocks:
- name: bpf
  id: variable
  parameters:
    comment: 'Value: firdes.complex_band_pass(1,samp_rate,(freqShift-90)*1000,(freqShift+90)*1000,30e3,5)'
    value: firdes.complex_band_pass(1,samp_rate,(freqShift-7.5)*1000,(freqShift+7.5)*1000,7.5e3,5)
  states: {}
- name: deviation
  id: variable
  parameters:
    value: 15e3
  states: {}
- name: freqShift
  id: variable_qtgui_range
  parameters:
    comment: |-
      This adjusts the bandpass filter
      start and stop frequency, NOT
      the center frequency of the SDR.
      ---------------------------------------------
      Start: -samp_rate/2000+100
      Stop: samp_rate/2000-100

      NOTE: The +/-100 in the "Start"
      and "Stop" values above are to
      ensure that the limits of the
      bandpass filter do not go past
      the Nyquist limit (sample rate / 2).
    label: Frequency Shift (kHz)
    start: '-samp_rate/2000+100'
    step: '25'
    stop: samp_rate/2000-100
    value: '0'
  states: {}
- name: rfGain
  id: variable_qtgui_range
  parameters:
    label: RF Gain (dB)
    start: '0'
    step: '1'
    stop: '50'
    value: '16'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.4e6
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    comment: |-
      NOTE: Volume defaults to a
      low value so as not to blow
      out your speakers!
    label: Volume (dB)
    start: '-100'
    step: '0.1'
    stop: '20'
    value: '-16'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    comment: |-
      Frequency demodulate
      ---------------------------------
      Gain: samp_rate/(2*math.pi*deviation)
    gain: samp_rate/(2*math.pi*deviation)
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    comment: |-
      This removes the DC offset
      due to the center frequency
      going into the Quad Demod
      block being non-zero.
      --------------------------------------
      Constant: -freqShift*1000/deviation
    const: '-freqShift*1000/deviation'
    type: float
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: int(len(bpf)/2)
    type: complex
  states: {}
- name: fft_filter_xxx_0
  id: fft_filter_xxx
  parameters:
    comment: |-
      Complex bandpass filter
      ------------------------------------
      Type: Complex->Complex (Complex Taps)
    decim: '1'
    taps: bpf
    type: ccc
  states: {}
- name: filter_fft_low_pass_filter_0
  id: filter_fft_low_pass_filter
  parameters:
    comment: |-
      "Gain" is used for 
      volume control.
      -----------------------
      Gain: 10**(volume/20)
    cutoff_freq: 15e3
    decim: '50'
    gain: 10**(volume/20)
    samp_rate: samp_rate
    type: fff
    width: 4e3
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '8192'
    label1: Full Spectrum
    label2: Filtered Signal
    nconnections: '2'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    legend: 'False'
    name: Baseband Signal
    size: '24000'
    srate: samp_rate
    type: float
    ymax: samp_rate/2/deviation
    ymin: '-samp_rate/2/deviation'
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: 162.3e6
    gain0: rfGain
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', blocks_add_const_vxx_0, '0']
- [analog_quadrature_demod_cf_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_add_const_vxx_0, '0', filter_fft_low_pass_filter_0, '0']
- [blocks_delay_0, '0', qtgui_freq_sink_x_0, '0']
- [fft_filter_xxx_0, '0', analog_quadrature_demod_cf_0, '0']
- [fft_filter_xxx_0, '0', qtgui_freq_sink_x_0, '1']
- [filter_fft_low_pass_filter_0, '0', audio_sink_0, '0']
- [rtlsdr_source_0, '0', blocks_delay_0, '0']
- [rtlsdr_source_0, '0', fft_filter_xxx_0, '0']

metadata:
  file_format: 1
