options:
  parameters:
    generate_options: qt_gui
    id: complex_spectrum
    output_language: python
    title: Complex Spectrum
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 2.4e6
  states: {}
- name: blocks_complex_to_imag_0
  id: blocks_complex_to_imag
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    gui_hint: 0,0,10,20
    label1: Original
    label2: Flipped
    name: Complex Spectrum
    nconnections: '2'
    type: complex
    ymax: '-20'
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    gui_hint: 10,0,10,20
    label1: Real
    label2: Imag
    name: Real-Only Spectrum
    nconnections: '2'
    type: float
    ymax: '-20'
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: 91.7e6
    gain0: '16'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_complex_to_imag_0, '0', blocks_float_to_complex_0, '0']
- [blocks_complex_to_imag_0, '0', qtgui_freq_sink_x_1, '1']
- [blocks_complex_to_real_0, '0', blocks_float_to_complex_0, '1']
- [blocks_complex_to_real_0, '0', qtgui_freq_sink_x_1, '0']
- [blocks_float_to_complex_0, '0', qtgui_freq_sink_x_0, '1']
- [rtlsdr_source_0, '0', blocks_complex_to_imag_0, '0']
- [rtlsdr_source_0, '0', blocks_complex_to_real_0, '0']
- [rtlsdr_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
