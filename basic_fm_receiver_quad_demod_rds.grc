options:
  parameters:
    author: Gary Schafer
    generate_options: qt_gui
    id: basic_fm_receiver_quad_demod_rds
    output_language: python
    title: Basic FM Receiver with RDS
  states: {}

blocks:
- name: cf
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,10
    label: Center Frequency (MHz)
    start: '87.7'
    step: '0.1'
    stop: '108'
    value: '90.9'
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,10,1,10
    label: RF Gain (dB)
    start: '0'
    step: '1'
    stop: '50'
    value: '10'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.4e6
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: '0.707'
    type: complex
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: (samp_rate/10)/(2*math.pi*85e3)
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: '2'
    type: byte
  states: {}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: 2*math.pi/100
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '2'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: '24'
    ted_gain: '1.0'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {}
- name: filter_fft_low_pass_filter_0_0
  id: filter_fft_low_pass_filter
  parameters:
    cutoff_freq: 90e3
    decim: '10'
    gain: '1'
    samp_rate: samp_rate
    type: ccc
    width: 30e3
    win: window.WIN_HAMMING
  states: {}
- name: filter_fft_rrc_filter_0
  id: filter_fft_rrc_filter
  parameters:
    alpha: '0.35'
    decim: '1'
    gain: '1'
    ntaps: 11*24
    samp_rate: 57e3
    sym_rate: 57e3/24
    type: ccc
  states: {}
- name: freq_xlating_fft_filter_ccc_0
  id: freq_xlating_fft_filter_ccc
  parameters:
    center_freq: 57e3
    decim: '5'
    samp_rate: samp_rate/10
    taps: firdes.low_pass(1,samp_rate/10,2400,1000,0)
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: myTabs
  id: qtgui_tab_widget
  parameters:
    gui_hint: 1,0,20,20
    label0: RF Spectrum
    label1: Baseband Processing
    num_tabs: '2'
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    color1: '"black"'
    grid: 'True'
    gui_hint: myTabs@1:0,0,10,7
    legend: 'False'
    name: RDS Constellation
    size: '475'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/10
    color1: '"black"'
    fc: '0'
    fftsize: '8192'
    freqhalf: 'False'
    grid: 'True'
    gui_hint: myTabs@0:0,0,20,20
    legend: 'False'
    name: RF Spectrum
    type: float
    ymax: '-20'
  states: {}
- name: qtgui_time_raster_sink_x_0
  id: qtgui_time_raster_sink_x
  parameters:
    color1: '2'
    gui_hint: myTabs@1:0,7,10,13
    ncols: '104'
    nrows: '256'
    samp_rate: '1187.5'
    type: byte
    zmin: '0'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '48'
    interp: '57'
    type: ccc
  states: {}
- name: rds_decoder_0
  id: rds_decoder
  parameters: {}
  states: {}
- name: rds_panel_0
  id: rds_panel
  parameters:
    gui_hint: myTabs@1:10,0,10,20
  states: {}
- name: rds_parser_0
  id: rds_parser
  parameters:
    pty_locale: '1'
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: cf*1e6
    gain0: rf_gain
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: rds_mod
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: costas
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: rds_mod
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: costas
  states: {}

connections:
- [analog_agc_xx_0, '0', digital_symbol_sync_xx_0, '0']
- [analog_quadrature_demod_cf_0, '0', blocks_float_to_complex_0, '0']
- [analog_quadrature_demod_cf_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_complex_to_real_0, '0', digital_binary_slicer_fb_0, '0']
- [blocks_float_to_complex_0, '0', freq_xlating_fft_filter_ccc_0, '0']
- [blocks_keep_one_in_n_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_binary_slicer_fb_0, '0', blocks_keep_one_in_n_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_costas_loop_cc_0, '0', virtual_sink_1, '0']
- [digital_diff_decoder_bb_0, '0', qtgui_time_raster_sink_x_0, '0']
- [digital_diff_decoder_bb_0, '0', rds_decoder_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_costas_loop_cc_0, '0']
- [filter_fft_low_pass_filter_0_0, '0', analog_quadrature_demod_cf_0, '0']
- [filter_fft_rrc_filter_0, '0', analog_agc_xx_0, '0']
- [freq_xlating_fft_filter_ccc_0, '0', rational_resampler_xxx_0, '0']
- [rational_resampler_xxx_0, '0', virtual_sink_0, '0']
- [rds_decoder_0, out, rds_parser_0, in]
- [rds_parser_0, out, rds_panel_0, in]
- [rtlsdr_source_0, '0', filter_fft_low_pass_filter_0_0, '0']
- [virtual_source_0, '0', filter_fft_rrc_filter_0, '0']
- [virtual_source_1, '0', blocks_complex_to_real_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
