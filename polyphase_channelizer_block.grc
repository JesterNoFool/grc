options:
  parameters:
    author: Gary Schafer
    generate_options: qt_gui
    id: polyphase_channelizer_block
    output_language: python
    title: Polyphase Channelizer Block Comparison
  states: {}

blocks:
- name: channel
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,20
    label: Channel
    rangeType: int
    start: '0'
    step: '1'
    stop: '11'
    value: '0'
  states: {}
- name: dec
  id: variable
  parameters:
    value: '12'
  states: {}
- name: numZeros
  id: variable
  parameters:
    value: dec-np.mod(protoLength,dec)
  states: {}
- name: padLength
  id: variable
  parameters:
    value: len(padTaps)
  states: {}
- name: padTaps
  id: variable
  parameters:
    value: '[*protoTaps,*zeropad]'
  states: {}
- name: protoLength
  id: variable
  parameters:
    value: len(protoTaps)
  states: {}
- name: protoTaps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: 90e3
    gain: '1.0'
    samp_rate: samp_rate
    width: 10e3
    win: window.WIN_HAMMING
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.4e6
  states: {}
- name: zeropad
  id: variable
  parameters:
    value: '[0,]*numZeros'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate/12/(2*math.pi*85e3)
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: channel
    num_inputs: dec
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: myTabs
  id: qtgui_tab_widget
  parameters:
    gui_hint: 1,0,20,20
    label0: Full Spectrum
    label1: Filtered Spectrum
    label2: Baseband (Demod) Spectrum
    num_tabs: '3'
  states: {}
- name: pfb_channelizer_ccf_0
  id: pfb_channelizer_ccf
  parameters:
    atten: '100'
    ch_map: '[7,8,9,10,11,0,1,2,3,4,5,6]'
    nchans: dec
    osr: '1.0'
    taps: protoTaps
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/dec
    color1: '"black"'
    fc: '0'
    fftsize: '2048'
    freqhalf: 'False'
    grid: 'True'
    gui_hint: myTabs@2
    legend: 'False'
    name: Baseband Spectrum
    type: float
    update_time: '0.01'
    ymax: '-20'
    ymin: '-120'
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    color1: '"black"'
    fc: '0'
    fftsize: '8192'
    grid: 'True'
    gui_hint: myTabs@0
    legend: 'False'
    name: RF Spectrum
    type: complex
    update_time: '0.01'
    ymax: '-20'
    ymin: '-120'
  states: {}
- name: qtgui_freq_sink_x_2
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    color1: '"black"'
    fc: '0'
    fftsize: '2048'
    grid: 'True'
    gui_hint: myTabs@1
    legend: 'False'
    name: Filtered Spectrum
    type: complex
    update_time: '0.01'
    ymax: '-20'
    ymin: '-120'
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: 91.9e6
    gain0: '18'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_selector_0, '0', analog_quadrature_demod_cf_0, '0']
- [blocks_selector_0, '0', qtgui_freq_sink_x_2, '0']
- [pfb_channelizer_ccf_0, '0', blocks_selector_0, '0']
- [pfb_channelizer_ccf_0, '1', blocks_selector_0, '1']
- [pfb_channelizer_ccf_0, '10', blocks_selector_0, '10']
- [pfb_channelizer_ccf_0, '11', blocks_selector_0, '11']
- [pfb_channelizer_ccf_0, '2', blocks_selector_0, '2']
- [pfb_channelizer_ccf_0, '3', blocks_selector_0, '3']
- [pfb_channelizer_ccf_0, '4', blocks_selector_0, '4']
- [pfb_channelizer_ccf_0, '5', blocks_selector_0, '5']
- [pfb_channelizer_ccf_0, '6', blocks_selector_0, '6']
- [pfb_channelizer_ccf_0, '7', blocks_selector_0, '7']
- [pfb_channelizer_ccf_0, '8', blocks_selector_0, '8']
- [pfb_channelizer_ccf_0, '9', blocks_selector_0, '9']
- [rtlsdr_source_0, '0', pfb_channelizer_ccf_0, '0']
- [rtlsdr_source_0, '0', qtgui_freq_sink_x_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
