options:
  parameters:
    author: Gary Schafer
    generate_options: qt_gui
    id: fftFiltering2Branch
    output_language: python
    title: FFT Filtering by Parts - 2 Branches
  states: {}

blocks:
- name: N
  id: variable
  parameters:
    value: 2**tapsExponent
  states: {}
- name: lpf
  id: variable
  parameters:
    comment: |-
      Create lowpass filter taps

      Value: firdes.low_pass(1,samp_rate,100e3,20e3,5)
    value: firdes.low_pass(1,samp_rate,100e3,20e3,5)
  states: {}
- name: lpfFft
  id: variable
  parameters:
    comment: |-
      Calculate the FFT of the
      zeropadded filter taps.
    value: np.fft.fft(lpfZero)
  states: {}
- name: lpfLength
  id: variable
  parameters:
    comment: 'Value: len(lpf)'
    value: len(lpf)
  states: {}
- name: lpfZero
  id: variable
  parameters:
    comment: Zeropad the filter taps
    value: lpf+[0,]*int(N-lpfLength)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.4e6
  states: {}
- name: tapsExponent
  id: variable
  parameters:
    value: int(np.log(lpfLength)/np.log(2))+2
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    comment: Frequency demod
    gain: samp_rate/(20*math.pi*100e3)
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_delay_0_1
  id: blocks_delay
  parameters:
    comment: 'Delay: int(N/2)'
    delay: int(N/2)
    type: complex
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/gary/SDR-Software/gnuradio/iq-files/FM Broadcast/FM-90M9CF-2M4FS-03.cf32
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    comment: |-
      Downsample by a
      factor of 10.
    n: '10'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/N
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_2
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/N
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_2_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_2_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    comment: |-
      Multiply FFT of filter
      taps with the FFT of the
      signal samples. This
      effectively convolves the
      filter and signal.
    const: lpfFft
    type: complex
    vlen: N
  states: {}
- name: blocks_multiply_const_vxx_1_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: |-
      Multiply FFT of filter
      taps with the FFT of the
      signal samples. This
      effectively convolves the
      filter and signal.
    const: lpfFft
    type: complex
    vlen: N
  states: {}
- name: blocks_stream_demux_0
  id: blocks_stream_demux
  parameters:
    comment: |-
      Separate input signal
      between two branches
    lengths: (int(N/2), int(N/2))
    type: complex
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    comment: |-
      Create time record

      Num Items: N
    num_items: N
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0
  id: blocks_stream_to_vector
  parameters:
    comment: |-
      Create time record

      Num Items: N
    num_items: N
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_vector_insert_x_0
  id: blocks_vector_insert_x
  parameters:
    comment: Zeropad the signal
    offset: int(N/2)
    period: N
    type: complex
    vector: (0,)*int(N/2)
  states: {}
- name: blocks_vector_insert_x_0_0
  id: blocks_vector_insert_x
  parameters:
    comment: Zeropad the signal
    offset: int(N/2)
    period: N
    type: complex
    vector: (0,)*int(N/2)
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: N
    type: complex
  states: {}
- name: blocks_vector_to_stream_0_1
  id: blocks_vector_to_stream
  parameters:
    num_items: N
    type: complex
  states: {}
- name: fft_filter_xxx_0
  id: fft_filter_xxx
  parameters:
    comment: |-
      Filter using standard
      GRC FFT filter.
    decim: '1'
    taps: lpf
    type: ccc
  states: {}
- name: fft_vxx_0_0
  id: fft_vxx
  parameters:
    comment: FFT of signal
    fft_size: N
    forward: 'True'
    shift: 'False'
    type: complex
    window: window.rectangular(N)
  states: {}
- name: fft_vxx_0_0_0
  id: fft_vxx
  parameters:
    comment: Convert back to time domain
    fft_size: N
    forward: 'False'
    shift: 'False'
    type: complex
    window: window.rectangular(N)
  states: {}
- name: fft_vxx_0_0_0_1
  id: fft_vxx
  parameters:
    comment: Convert back to time domain
    fft_size: N
    forward: 'False'
    shift: 'False'
    type: complex
    window: window.rectangular(N)
  states: {}
- name: fft_vxx_0_0_1
  id: fft_vxx
  parameters:
    comment: FFT of signal
    fft_size: N
    forward: 'True'
    shift: 'False'
    type: complex
    window: window.rectangular(N)
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: lpf
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: myTabs
  id: qtgui_tab_widget
  parameters:
    gui_hint: 1,0,20,20
    label0: Branches - Time Domain
    label1: Filtered Spectrum Comparison
    label2: Time Domain Comparison
    label3: Baseband Spectrum
    num_tabs: '4'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '8192'
    grid: 'True'
    gui_hint: myTabs@1
    label1: ByParts
    label2: GRC FFT
    label3: GRC Time Domain
    name: FFT Filter by Parts vs GRC FFT Filter
    nconnections: '3'
    type: complex
    update_time: '0.1'
    ymax: '0'
    ymin: '-120'
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/10
    color1: '"black"'
    fc: '0'
    fftsize: '8192'
    freqhalf: 'False'
    grid: 'True'
    gui_hint: myTabs@3
    label1: ByParts
    legend: 'False'
    name: Demodulated Spectrum
    type: float
    update_time: '0.1'
    ymax: '-20'
    ymin: '-120'
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    color5: dark blue
    grid: 'True'
    gui_hint: myTabs@2
    label1: ByParts I
    label2: ByParts Q
    label3: Standard I
    label4: Standard Q
    label5: Time Domain I
    label6: Time Domain Q
    name: FFT Filter by Parts vs GRC FFT Filter
    nconnections: '3'
    size: '4096'
    srate: samp_rate
    type: complex
    update_time: '0.1'
    ymax: '1.25'
    ymin: '-1.25'
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    color5: dark blue
    grid: 'True'
    gui_hint: myTabs@0
    label1: Branch A - I
    label2: Branch A - Q
    label3: Branch B - I
    label4: Branch B - Q
    label5: Final Signal - I
    label6: Final Signal - Q
    name: Two Branches
    nconnections: '3'
    size: int(4*N)
    srate: '1'
    type: complex
    update_time: '0.1'
    ymax: '2.25'
    ymin: '-2.25'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: grcFftFilter
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: grcTimeFilter
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: grcFftFilter
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: grcTimeFilter
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', qtgui_freq_sink_x_0_0, '0']
- [blocks_add_xx_0, '0', blocks_keep_one_in_n_0, '0']
- [blocks_add_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_add_xx_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_add_xx_0, '0', qtgui_time_sink_x_0_0_0, '2']
- [blocks_delay_0_1, '0', blocks_add_xx_0, '1']
- [blocks_delay_0_1, '0', qtgui_time_sink_x_0_0_0, '1']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_keep_one_in_n_0, '0', analog_quadrature_demod_cf_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_xx_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [blocks_multiply_const_vxx_0_2, '0', blocks_delay_0_1, '0']
- [blocks_multiply_const_vxx_0_2_0, '0', qtgui_freq_sink_x_0, '1']
- [blocks_multiply_const_vxx_0_2_0, '0', qtgui_time_sink_x_0_0, '1']
- [blocks_multiply_const_vxx_0_2_0_0, '0', qtgui_freq_sink_x_0, '2']
- [blocks_multiply_const_vxx_0_2_0_0, '0', qtgui_time_sink_x_0_0, '2']
- [blocks_multiply_const_vxx_1, '0', fft_vxx_0_0_0, '0']
- [blocks_multiply_const_vxx_1_0, '0', fft_vxx_0_0_0_1, '0']
- [blocks_stream_demux_0, '0', blocks_vector_insert_x_0_0, '0']
- [blocks_stream_demux_0, '1', blocks_vector_insert_x_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0_0, '0']
- [blocks_stream_to_vector_0_0, '0', fft_vxx_0_0_1, '0']
- [blocks_throttle_0, '0', blocks_stream_demux_0, '0']
- [blocks_throttle_0, '0', fft_filter_xxx_0, '0']
- [blocks_throttle_0, '0', fir_filter_xxx_0, '0']
- [blocks_vector_insert_x_0, '0', blocks_stream_to_vector_0_0, '0']
- [blocks_vector_insert_x_0_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_vector_to_stream_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_vector_to_stream_0_1, '0', blocks_multiply_const_vxx_0_2, '0']
- [fft_filter_xxx_0, '0', virtual_sink_0, '0']
- [fft_vxx_0_0, '0', blocks_multiply_const_vxx_1, '0']
- [fft_vxx_0_0_0, '0', blocks_vector_to_stream_0, '0']
- [fft_vxx_0_0_0_1, '0', blocks_vector_to_stream_0_1, '0']
- [fft_vxx_0_0_1, '0', blocks_multiply_const_vxx_1_0, '0']
- [fir_filter_xxx_0, '0', virtual_sink_0_0, '0']
- [virtual_source_0, '0', blocks_multiply_const_vxx_0_2_0, '0']
- [virtual_source_0_0, '0', blocks_multiply_const_vxx_0_2_0_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
