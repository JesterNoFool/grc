options:
  parameters:
    author: Gary Schafer
    generate_options: qt_gui
    id: basic_fm_receiver_wbfm
    output_language: python
    title: Basic FM Receiver
  states: {}

blocks:
- name: cf
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,10
    label: Center Frequency (MHz)
    start: '87.7'
    step: '0.1'
    stop: '108'
    value: '90.9'
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,10,1,10
    label: RF Gain (dB)
    start: '0'
    step: '1'
    stop: '50'
    value: '10'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.4e6
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,10
    label: Volume (dB)
    start: '-130'
    step: '0.1'
    stop: '20'
    value: '-10'
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: '5'
    quad_rate: 240e3
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: Volume control
    const: 10**(volume/20)
    type: float
  states: {}
- name: filter_fft_low_pass_filter_0
  id: filter_fft_low_pass_filter
  parameters:
    cutoff_freq: 90e3
    decim: '10'
    gain: '1'
    samp_rate: samp_rate
    type: ccc
    width: 20e3
    win: window.WIN_HAMMING
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    color1: '"black"'
    fc: cf*1e6
    fftsize: '8192'
    grid: 'True'
    gui_hint: 2,0,20,20
    legend: 'False'
    type: complex
    ymax: '-20'
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: cf*1e6
    gain0: rf_gain
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_wfm_rcv_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [filter_fft_low_pass_filter_0, '0', analog_wfm_rcv_0, '0']
- [rtlsdr_source_0, '0', filter_fft_low_pass_filter_0, '0']
- [rtlsdr_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
