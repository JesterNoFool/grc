options:
  parameters:
    author: Gary Schafer
    generate_options: qt_gui
    id: videoRasterBaseband
    output_language: python
    title: Raster of Baseband Video
  states: {}

blocks:
- name: brightness
  id: variable_qtgui_range
  parameters:
    label: Brightness
    start: '-1000'
    step: '1'
    stop: '1000'
    value: '45'
  states: {}
- name: clockDiv
  id: variable
  parameters:
    comment: |-
      USER ENTERED
      VARIABLE
      Constant based on
      video type:

      NTSC: 143
      PAL/SECAM: 144
    value: '143'
  states: {}
- name: contrast
  id: variable_qtgui_range
  parameters:
    label: Contrast (dB)
    start: '-100'
    step: '0.01'
    stop: '100'
    value: '0'
  states: {}
- name: horzPts
  id: variable
  parameters:
    comment: |-
      This is the number of horizontal
      pixels that will be displayed on
      the Video SDL Sink. It is based
      on the following calculation:

      Value: int(videoRate/horzRateBase)
    value: int(videoRate/horzRateBase)
  states: {}
- name: horzRate
  id: variable_qtgui_range
  parameters:
    comment: |-
      Used to set the adjustment
      for the horizontal line rate.

      Default: horzRateBase
      Start: horzRateBase-10
      Stop: horzRateBase+10
    label: Horizontal Rate (Hz)
    start: horzRateBase-10
    step: '0.001'
    stop: horzRateBase+10
    value: horzRateBase
  states: {}
- name: horzRateBase
  id: variable
  parameters:
    comment: |-
      Calculate the basic
      horizontal line rate.

      Value: 2.25e6/clockDiv
    value: 2.25e6/clockDiv
  states: {}
- name: horzShift
  id: variable_qtgui_range
  parameters:
    comment: |-
      Shift the display left / right.
      Type: int
      Default value: horzPts
      Start: 0
      Stop: int(horzPts*2)
    label: Horizontal Shift (pixels)
    rangeType: int
    start: '0'
    step: '1'
    stop: int(horzPts*2)
    value: horzPts
  states: {}
- name: numLines
  id: variable
  parameters:
    comment: |-
      USER ENTERED
      VARIABLE
      Set the number of lines.

      NTSC: 525
      PAL/SECAM: 625
    value: '525'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: |-
      USER ENTERED
      VARIABLE
    value: 9e6
  states: {}
- name: vertShift
  id: variable_qtgui_range
  parameters:
    comment: |-
      Adjust the display vertically.
      Type: int
      Default value: numLines
      Start: 0
      Stop: int(numLines*2)
    label: Vertical Shift (lines)
    rangeType: int
    start: '0'
    step: '1'
    stop: int(numLines*2)
    value: numLines
  states: {}
- name: videoRate
  id: variable
  parameters:
    comment: |-
      USER ENTERED VARIABLE.
      Sample rate needed
      for specific video type.

      NTSC: 9e6, 13.5e6, 18e6, etc.
      PAL/SECAM: 14e6, 16e6, 18e6, etc.
    value: 9e6
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    comment: |-
      Brightness adjust

      Constant: brightness
    const: brightness
    type: float
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    comment: |-
      Delay by half-frame

      Delay: int(horzPts*int(numLines/2))
    delay: int(horzPts*int(numLines/2))
    type: byte
  states: {}
- name: blocks_delay_1
  id: blocks_delay
  parameters:
    comment: |-
      Adjust the horizontal  and
      vertical position of the live
      display when running

      Delay: horzShift+int(vertShift*horzPts)
    delay: horzShift+int(vertShift*horzPts)
    type: float
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/gary/ffmpeg/ntscVideoFryLaurie-9M0FS.rs16
    repeat: 'True'
    type: short
  states: {}
- name: blocks_float_to_uchar_0
  id: blocks_float_to_uchar
  parameters:
    comment: |-
      Change to data type required
      by the Video SDL Sink
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    comment: |-
      Scale from signed 16-bit
      integer to 32-bit floats
      and adjust contrast.

      Scale: 2**15/(10**(contrast/20))
    scale: 2**15/(10**(contrast/20))
  states: {}
- name: blocks_stream_mux_0
  id: blocks_stream_mux
  parameters:
    comment: |-
      This block plus the delay feeding
      the lower input (Input 1) combined
      provide for the interlacing of
      analog video.

      Lengths: (horzPts, horzPts)
    lengths: (horzPts, horzPts)
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: float
  states: {}
- name: filter_fft_low_pass_filter_0
  id: filter_fft_low_pass_filter
  parameters:
    comment: |-
      Baseband filter. The cutoff
      frequency depends on the
      video type.
      NTSC:
      Cutoff freq: 4.2e6
      PAL/SECAM:
      Cutoff freq: 6e6
    cutoff_freq: 4.2e6
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fff
    width: 50e3
    win: window.WIN_BLACKMAN
  states: {}
- name: import_0
  id: import
  parameters:
    comment: |-
      Import: 
      import numpy as np
    imports: import numpy as np
  states: {}
- name: import_0_0
  id: import
  parameters:
    comment: 'Import: import math'
    imports: import math
  states: {}
- name: pfb_arb_resampler_xxx_0
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    comment: |-
      Perform adjustment of input sample
      rate to the required video sample
      rate, & fine adjustment of sample
      rate to account for differences in
      clocks between transmitter and SDR.

      Resampling Rate: (horzRate*horzPts)/samp_rate
    nfilts: '32'
    rrate: (horzRate*horzPts)/samp_rate
    type: fff
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    comment: |-
      Display the video signal
      so that it can be adjusted
      to be within the amplitude
      limits of 0 - 255.

      Number of Points: int(horzPts*2)
      Sample Rate: videoRate
      Ymin: 0
      Ymax: 255
    grid: 'True'
    legend: 'False'
    name: Adjust Video to Within Amplitude Limits
    size: int(horzPts*numLines)
    srate: videoRate
    type: float
    ymax: '255'
    ymin: '0'
  states: {}
- name: video_sdl_sink_0
  id: video_sdl_sink
  parameters:
    comment: |-
      This will display the actual,
      live video. Use the display
      width and display height
      to account for widescreen
      vs 4:3 ratio.

      Input Width: horzPts
      Input Height: numLines
    display_height: '800'
    display_width: '1440'
    fps: '0'
    height: numLines
    type: byte
    width: horzPts
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: rationalOut
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: resampleOut
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: rationalOut
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: resampleOut
  states: {}

connections:
- [blocks_add_const_vxx_0, '0', blocks_delay_1, '0']
- [blocks_delay_0, '0', blocks_stream_mux_0, '1']
- [blocks_delay_1, '0', qtgui_time_sink_x_0, '0']
- [blocks_delay_1, '0', virtual_sink_1, '0']
- [blocks_file_source_0, '0', blocks_short_to_float_0, '0']
- [blocks_float_to_uchar_0, '0', blocks_delay_0, '0']
- [blocks_float_to_uchar_0, '0', blocks_stream_mux_0, '0']
- [blocks_short_to_float_0, '0', filter_fft_low_pass_filter_0, '0']
- [blocks_stream_mux_0, '0', video_sdl_sink_0, '0']
- [blocks_throttle_0, '0', virtual_sink_0, '0']
- [filter_fft_low_pass_filter_0, '0', blocks_throttle_0, '0']
- [pfb_arb_resampler_xxx_0, '0', blocks_add_const_vxx_0, '0']
- [virtual_source_0, '0', pfb_arb_resampler_xxx_0, '0']
- [virtual_source_1, '0', blocks_float_to_uchar_0, '0']

metadata:
  file_format: 1
