options:
  parameters:
    author: Gary Schafer
    generate_options: qt_gui
    id: basic_spectral_display
    output_language: python
    title: Building a Basic Spectral Display
  states: {}

blocks:
- name: N
  id: variable
  parameters:
    value: '2048'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.4e6
  states: {}
- name: w
  id: variable
  parameters:
    value: window.blackmanharris(N)
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    vlen: N
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/gary/SDR-Software/gnuradio/iq-files/FM Broadcast/FM-broadcast-91M8CF-2M4FS-20250112-01.cf32
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: w
    type: complex
    vlen: N
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
    vlen: N
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: '2'
    type: float
    vlen: N
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: N
    type: complex
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: N
    type: float
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: N
    forward: 'True'
    shift: 'True'
    type: complex
    window: '[1/N,]*N'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: N
    type: complex
  states: {}
- name: qtgui_time_raster_sink_x_0
  id: qtgui_time_raster_sink_x
  parameters:
    ncols: N
    nrows: '256'
    samp_rate: samp_rate
    type: float
    zmax: '10'
    zmin: '-140'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: N
    srate: samp_rate
    type: float
    ymax: '10'
    ymin: '-140'
  states: {state: disabled}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    vlen: N
    x_axis_label: '"Frequency (MHz)"'
    x_start: '-samp_rate/2e6'
    x_step: samp_rate/N/1e6
    x_units: '"MHz"'
    y_axis_label: '"Amplitude (dB)"'
    y_units: '"dB"'
  states: {}

connections:
- [blocks_complex_to_mag_squared_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_multiply_const_vxx_0, '0', fft_vxx_0, '0']
- [blocks_nlog10_ff_0, '0', blocks_repeat_0, '0']
- [blocks_nlog10_ff_0, '0', blocks_vector_to_stream_0, '0']
- [blocks_repeat_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_stream_to_vector_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_throttle2_0, '0', blocks_stream_to_vector_0, '0']
- [blocks_throttle2_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_vector_to_stream_0, '0', qtgui_time_raster_sink_x_0, '0']
- [blocks_vector_to_stream_0, '0', qtgui_time_sink_x_0, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_squared_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
