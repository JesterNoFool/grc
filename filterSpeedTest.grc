options:
  parameters:
    author: Gary Schafer
    generate_options: qt_gui
    id: filterSpeedTest
    output_language: python
    title: Test of Convolution & FFT Filter Speeds
  states: {}

blocks:
- name: lpf
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: 100e3
    gain: '1.0'
    samp_rate: samp_rate
    width: 20e3
    win: window.WIN_HAMMING
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.4e6
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_probe_rate_0
  id: blocks_probe_rate
  parameters:
    alpha: '0.15'
    mintime: '1000'
    type: complex
  states: {}
- name: fft_filter_xxx_0
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: lpf
    type: ccf
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: lpf
    type: ccf
  states: {state: disabled}

connections:
- [blocks_null_source_0, '0', fft_filter_xxx_0, '0']
- [blocks_null_source_0, '0', fir_filter_xxx_0, '0']
- [blocks_probe_rate_0, rate, blocks_message_debug_0, print]
- [fft_filter_xxx_0, '0', blocks_probe_rate_0, '0']
- [fir_filter_xxx_0, '0', blocks_probe_rate_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
