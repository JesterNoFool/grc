options:
  parameters:
    author: gary
    generate_options: qt_gui
    id: timeDomainAliasing
    output_language: python
    title: Time Domain Filter Smearing
  states: {}

blocks:
- name: N
  id: variable
  parameters:
    value: 2**10
  states: {}
- name: lpf
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: 100e3
    gain: '1.0'
    samp_rate: samp_rate
    width: 20e3
    win: window.WIN_HAMMING
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.4e6
  states: {}
- name: tap_length
  id: variable
  parameters:
    value: len(lpf)
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/gary/SDR-Software/gnuradio/iq-files/FM Broadcast/FM-90M9CF-2M4FS-03.cf32
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_stream_mux_0
  id: blocks_stream_mux
  parameters:
    lengths: (int(N/2),int(N/2))
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: fft_filter_xxx_0
  id: fft_filter_xxx
  parameters:
    decim: '1'
    taps: lpf
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    label1: Unfiltered - I
    label2: Unfiltered - Q
    label3: Filtered - I
    label4: Filtered - Q
    nconnections: '2'
    size: N
    srate: '1'
    type: complex
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_null_source_0, '0', blocks_stream_mux_0, '1']
- [blocks_stream_mux_0, '0', fft_filter_xxx_0, '0']
- [blocks_stream_mux_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_throttle_0, '0', blocks_stream_mux_0, '0']
- [fft_filter_xxx_0, '0', qtgui_time_sink_x_0, '1']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
