options:
  parameters:
    generate_options: qt_gui
    id: rds_demod
    output_language: python
    title: RDS Demodulator
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: 2.4e6
  states: {}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: '65536'
    rate: '1e-4'
    reference: '1.0'
    type: complex
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: (samp_rate/10)/(2*np.pi*85e3)
  states: {}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/gary/SDR-Software/gnuradio/iq-files/FM Broadcast/FM_broadcast_91M7CF_2M4FS_20260314.cf32
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: float
  states: {}
- name: blocks_rotator_cc_0
  id: blocks_rotator_cc
  parameters:
    phase_inc: 2*np.pi*800e3/samp_rate
  states: {}
- name: blocks_rotator_cc_0_0
  id: blocks_rotator_cc
  parameters:
    phase_inc: 2*np.pi*57e3/(samp_rate/10)
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {state: disabled}
- name: digital_binary_slicer_fb_0
  id: digital_binary_slicer_fb
  parameters: {}
  states: {}
- name: digital_costas_loop_cc_0
  id: digital_costas_loop_cc
  parameters:
    order: '2'
    w: 2*np.pi/100
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '2'
  states: {}
- name: digital_symbol_sync_xx_0
  id: digital_symbol_sync_xx
  parameters:
    damping: '1.0'
    loop_bw: '0.045'
    max_dev: '1.5'
    osps: '1'
    resamp_type: digital.IR_MMSE_8TAP
    sps: '48'
    ted_gain: '1.0'
    ted_type: digital.TED_SIGNAL_TIMES_SLOPE_ML
    type: cc
  states: {}
- name: filter_fft_low_pass_filter_0
  id: filter_fft_low_pass_filter
  parameters:
    cutoff_freq: 100e3
    decim: '10'
    gain: '1'
    samp_rate: samp_rate
    type: ccf
    width: 20e3
    win: window.WIN_HAMMING
  states: {}
- name: filter_fft_rrc_filter_0
  id: filter_fft_rrc_filter
  parameters:
    alpha: '0.35'
    decim: '1'
    gain: '1'
    ntaps: 11*48
    samp_rate: 57e3
    sym_rate: '2375'
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/10
    fc: '0'
    fftsize: '4096'
    type: complex
  states: {state: disabled}
- name: qtgui_time_raster_sink_x_0
  id: qtgui_time_raster_sink_x
  parameters:
    color1: '1'
    ncols: '104'
    nrows: '256'
    samp_rate: '1187.5'
    type: byte
    zmin: '0'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '104'
    srate: '1'
    type: float
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '240'
    interp: '57'
    type: ccc
  states: {}
- name: rds_decoder_0
  id: rds_decoder
  parameters: {}
  states: {}
- name: rds_panel_0
  id: rds_panel
  parameters: {}
  states: {}
- name: rds_parser_0
  id: rds_parser
  parameters:
    pty_locale: '1'
  states: {}

connections:
- [analog_agc_xx_0, '0', digital_symbol_sync_xx_0, '0']
- [analog_quadrature_demod_cf_0, '0', blocks_float_to_complex_0, '0']
- [blocks_complex_to_real_0, '0', digital_binary_slicer_fb_0, '0']
- [blocks_file_source_0, '0', blocks_throttle2_0, '0']
- [blocks_float_to_complex_0, '0', blocks_rotator_cc_0_0, '0']
- [blocks_null_source_0, '0', blocks_float_to_complex_0, '1']
- [blocks_rotator_cc_0, '0', filter_fft_low_pass_filter_0, '0']
- [blocks_rotator_cc_0_0, '0', rational_resampler_xxx_0, '0']
- [blocks_throttle2_0, '0', blocks_rotator_cc_0, '0']
- [blocks_uchar_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [digital_binary_slicer_fb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_costas_loop_cc_0, '0', blocks_complex_to_real_0, '0']
- [digital_costas_loop_cc_0, '0', qtgui_const_sink_x_0, '0']
- [digital_diff_decoder_bb_0, '0', blocks_uchar_to_float_0, '0']
- [digital_diff_decoder_bb_0, '0', qtgui_time_raster_sink_x_0, '0']
- [digital_diff_decoder_bb_0, '0', rds_decoder_0, '0']
- [digital_symbol_sync_xx_0, '0', digital_costas_loop_cc_0, '0']
- [filter_fft_low_pass_filter_0, '0', analog_quadrature_demod_cf_0, '0']
- [filter_fft_rrc_filter_0, '0', analog_agc_xx_0, '0']
- [filter_fft_rrc_filter_0, '0', qtgui_freq_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', filter_fft_rrc_filter_0, '0']
- [rds_decoder_0, out, rds_parser_0, in]
- [rds_parser_0, out, rds_panel_0, in]

metadata:
  file_format: 1
  grc_version: 3.10.9.2
