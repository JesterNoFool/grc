options:
  parameters:
    author: Gary Schafer
    generate_options: qt_gui
    id: analogHackrfProSpecAn
    output_language: python
    title: Create an Analog Spectrum Analyzer for HackRF Pro
  states: {}

blocks:
- name: N
  id: variable
  parameters:
    value: 2**fftLength
  states: {}
- name: cf
  id: variable
  parameters:
    comment: |-
      Center frequency
      in MHz.
    value: '91'
  states: {}
- name: fftLength
  id: variable
  parameters:
    comment: |-
      Calculate an exponent
      to set the FFT display
      so that is is close to the 
      value of the RBW
    value: np.round(np.log(2.004*samp_rate/rbw)/np.log(2))
  states: {}
- name: fft_rbw
  id: variable_qtgui_label
  parameters:
    gui_hint: 22,0,1,10
    label: 'FFT RBW (ENBW): '
    type: real
    value: samp_rate/N*2.004353
  states: {}
- name: halfrate
  id: variable
  parameters:
    comment: |-
      Used to normalize
      various values
      Value: samp_rate/2e6
    value: samp_rate/2e6
  states: {}
- name: horzLine
  id: variable
  parameters:
    comment: |-
      This creates the horizontal
      ramp.
      Value: np.arange(-1,1,2/pts)
    value: np.arange(-1,1,2/pts)
  states: {}
- name: if_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,10
    label: 'IF Gain (dB): '
    start: '0'
    step: '1'
    stop: '50'
    value: '28'
  states: {}
- name: pts
  id: variable
  parameters:
    comment: 'Value: int(samp_rate*swpTime)'
    value: int(samp_rate*swpTime)
  states: {}
- name: rbw
  id: variable_qtgui_label
  parameters:
    gui_hint: 1,0,1,10
    label: 'Resolution bandwidth (Hz): '
    type: real
    value: 40e3
  states: {}
- name: rbwTaps
  id: variable
  parameters:
    comment: |-
      Create the resolution bandwidth filter
      Value: firdes.low_pass(1,samp_rate,rbw/2,rbw/2,0)
    value: firdes.low_pass(1,samp_rate,rbw/2,rbw/2,0)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 5e6
  states: {}
- name: start_freq
  id: variable
  parameters:
    comment: |-
      Set start frequency
      of display
      Value: cf-halfrate
    value: cf-halfrate
  states: {}
- name: stop_freq
  id: variable
  parameters:
    comment: |-
      Set stop frequency
      of display
      Value: cf+halfrate
    value: cf+halfrate
  states: {}
- name: sweep_speed
  id: variable
  parameters:
    comment: |-
      Hz/sec
      Value: rbw*samp_rate/len(rbwTaps)
    value: rbw*samp_rate/len(rbwTaps)
  states: {}
- name: swpTime
  id: variable_qtgui_label
  parameters:
    comment: 'Default value: samp_rate/sweep_speed'
    gui_hint: 1,10,1,10
    label: 'Sweep Time (sec): '
    type: real
    value: samp_rate/sweep_speed
  states: {}
- name: vga_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,10,1,10
    label: 'VGA Gain (dB): '
    start: '0'
    step: '1'
    stop: '50'
    value: '24'
  states: {}
- name: analog_frequency_modulator_fc_0
  id: analog_frequency_modulator_fc
  parameters:
    comment: |-
      VCO (voltage controlled oscillator)
      Sensitivity: -np.pi
    sensitivity: '-np.pi'
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    comment: |-
      Set center frequency
      of display
    const: cf
    type: float
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters:
    comment: AM detector
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    comment: 'Delay: int(len(rbwTaps)/2)'
    delay: int(len(rbwTaps)/2)
    type: float
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters:
    comment: |-
      Create X-Y samples
      for constellation
      sink.
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    comment: |-
      Scale frequency
      (horizontal) axis
    const: halfrate
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    comment: Peak gain correction
    const: '2.7902'
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    comment: Mixer
    type: complex
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    comment: |-
      Convert linear
      to logarithmic
      n: 10
    k: '0'
    n: '10'
  states: {}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    comment: Ramp generator
    repeat: 'True'
    type: float
    vector: horzLine
  states: {}
- name: fft_filter_xxx_0
  id: fft_filter_xxx
  parameters:
    comment: RBW filter
    decim: '1'
    taps: rbwTaps
    type: ccc
  states: {}
- name: filter_fft_low_pass_filter_0
  id: filter_fft_low_pass_filter
  parameters:
    comment: |-
      Get rid of "Atari effect"
      issues.
    cutoff_freq: samp_rate*0.45
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: ccc
    width: samp_rate*0.05
    win: window.WIN_BLACKMAN
  states: {}
- name: import_1
  id: import
  parameters:
    comment: 'Import: import numpy as np'
    imports: import numpy as np
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    color1: '"black"'
    comment: |-
      Number of Points: pts
      Ymin: -100
      Ymax: 0
      Xmin: start_freq
      Xmax: stop_freq
      Update Period: 0.001
    grid: 'True'
    gui_hint: 2,0,20,20
    legend: 'False'
    marker1: '-1'
    name: Analog Spectrum
    size: len(horzLine)
    style1: '1'
    type: complex
    update_time: '0.001'
    xmax: stop_freq
    xmin: start_freq
    ymax: '0'
    ymin: '-100'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    comment: 'Update Period: swpTime'
    fc: cf*1e6
    fftsize: int(N)
    grid: 'True'
    gui_hint: 23,0,20,20
    label1: FFT Spectrum
    legend: 'False'
    name: FFT Spectrum
    type: complex
    update_time: swpTime
    ymax: '0'
    ymin: '-100'
  states: {}
- name: soapy_hackrf_source_0
  id: soapy_hackrf_source
  parameters:
    amp: 'True'
    center_freq: cf*1e6
    gain: if_gain
    samp_rate: samp_rate
    type: fc32
    vga: vga_gain
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: sweptOut
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: sweptOut
  states: {}

connections:
- [analog_frequency_modulator_fc_0, '0', blocks_multiply_xx_0, '1']
- [blocks_add_const_vxx_0, '0', blocks_float_to_complex_0, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_delay_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_float_to_complex_0, '0', qtgui_const_sink_x_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_multiply_const_vxx_1, '0', qtgui_freq_sink_x_0, '0']
- [blocks_multiply_xx_0, '0', virtual_sink_0, '0']
- [blocks_nlog10_ff_0, '0', blocks_float_to_complex_0, '1']
- [blocks_vector_source_x_0, '0', analog_frequency_modulator_fc_0, '0']
- [blocks_vector_source_x_0, '0', blocks_delay_0, '0']
- [fft_filter_xxx_0, '0', blocks_complex_to_mag_squared_0, '0']
- [filter_fft_low_pass_filter_0, '0', blocks_multiply_const_vxx_1, '0']
- [filter_fft_low_pass_filter_0, '0', blocks_multiply_xx_0, '0']
- [soapy_hackrf_source_0, '0', filter_fft_low_pass_filter_0, '0']
- [virtual_source_0, '0', fft_filter_xxx_0, '0']

metadata:
  file_format: 1
