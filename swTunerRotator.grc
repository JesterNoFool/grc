options:
  parameters:
    author: Gary Schafer
    generate_options: qt_gui
    id: swTunerRotator
    output_language: python
    title: Software Tuner - Rotator
  states: {}

blocks:
- name: cf
  id: variable_qtgui_entry
  parameters:
    gui_hint: 0,0,1,10
    label: Center Frequency (MHz)
    type: real
    value: '162.3'
  states: {}
- name: freqShift
  id: variable_qtgui_range
  parameters:
    label: Frequency Shift (kHz)
    start: '-samp_rate/1000'
    step: '1'
    stop: samp_rate/1000
    value: '100'
  states: {}
- name: rfGain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,10,1,10
    label: RF Gain (dB)
    start: '0'
    step: '1'
    stop: '50'
    value: '20'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.4e6
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    comment: |-
      Create line at center
      frequency.
    const: '10'
    type: complex
  states: {}
- name: analog_const_source_x_1
  id: analog_const_source_x
  parameters:
    const: '1'
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: iir_filter_xxx_0
  id: iir_filter_xxx
  parameters:
    comment: |-
      Feed-forward Taps: (1,-1)
      Feedback Taps: (1,np.exp(-2000j*np.pi*freqShift/samp_rate))
    fbtaps: (1,np.exp(-2000j*np.pi*freqShift/samp_rate))
    fftaps: (1,-1)
    type: ccz
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: 2,15,20,5
    size: '2400'
    style1: '1'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: cf*1e6+(1000*freqShift)
    fftsize: '16384'
    grid: 'True'
    gui_hint: 2,0,20,15
    label1: Spectrum
    label2: CF
    nconnections: '2'
    type: complex
    ymax: '-20'
    ymin: '-120'
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: cf*1e6
    gain0: rfGain
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_const_source_x_0, '0', qtgui_freq_sink_x_0, '1']
- [analog_const_source_x_1, '0', iir_filter_xxx_0, '0']
- [blocks_multiply_xx_0, '0', qtgui_freq_sink_x_0, '0']
- [iir_filter_xxx_0, '0', blocks_multiply_xx_0, '1']
- [iir_filter_xxx_0, '0', qtgui_const_sink_x_0, '0']
- [rtlsdr_source_0, '0', blocks_multiply_xx_0, '0']

metadata:
  file_format: 1
