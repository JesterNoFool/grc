options:
  parameters:
    author: Gary Schafer
    generate_options: qt_gui
    id: basic_fm_receiver_components
    output_language: python
    title: Basic FM Receiver
  states: {}

blocks:
- name: cf
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,10
    label: Center Frequency (MHz)
    start: '87.7'
    step: '0.1'
    stop: '108'
    value: '90.9'
  states: {}
- name: rf_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,10,1,10
    label: RF Gain (dB)
    start: '0'
    step: '1'
    stop: '50'
    value: '10'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.4e6
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    gui_hint: 1,0,1,10
    label: Volume (dB)
    start: '-130'
    step: '0.1'
    stop: '20'
    value: '-10'
  states: {}
- name: analog_fm_deemph_0
  id: analog_fm_deemph
  parameters:
    samp_rate: 48e3
    tau: '75e-6'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_complex_to_arg_0
  id: blocks_complex_to_arg
  parameters: {}
  states: {}
- name: blocks_conjugate_cc_0
  id: blocks_conjugate_cc
  parameters: {}
  states: {}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '1'
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: filter_fft_low_pass_filter_0
  id: filter_fft_low_pass_filter
  parameters:
    cutoff_freq: 90e3
    decim: '10'
    gain: '1'
    samp_rate: samp_rate
    type: ccc
    width: 20e3
    win: window.WIN_HAMMING
  states: {}
- name: filter_fft_low_pass_filter_1
  id: filter_fft_low_pass_filter
  parameters:
    comment: |-
      This block acts as filter, downsampler,
      and audio gain. The gain value is both
      for the FM demodulator (the "Gain" value
      of the Quad Demod block) and audio
      volume control.
      -----------------------------------------------------
      Gain: 10**(volume/20)*(samp_rate/10)/(2*math.pi*75e3)
    cutoff_freq: '22500'
    decim: '5'
    gain: 10**(volume/20)*(samp_rate/10)/(2*math.pi*75e3)
    samp_rate: samp_rate/10
    type: fff
    width: '1500'
    win: window.WIN_HAMMING
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import math
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      The blocks from the delay to the "Complex to Arg"
      block recreate the basic FM demodulator block
      called the "Quadrature Demod" block (Quad Demod,
      for short). These blocks in this configuration
      create a polar discriminator. The last block is
      normally a "Multiply Const" block to handle
      the "Gain" value, but this is being handled by the
      "Gain" value of the lowpass filter just after the
      "Complex to Arg" block.
    note: Quad Demod Components
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    color1: '"black"'
    fc: cf*1e6
    fftsize: '8192'
    grid: 'True'
    gui_hint: 2,0,20,20
    legend: 'False'
    type: complex
    ymax: '-20'
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: cf*1e6
    gain0: rf_gain
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_fm_deemph_0, '0', audio_sink_0, '0']
- [blocks_complex_to_arg_0, '0', filter_fft_low_pass_filter_1, '0']
- [blocks_conjugate_cc_0, '0', blocks_multiply_xx_0, '1']
- [blocks_delay_0, '0', blocks_conjugate_cc_0, '0']
- [blocks_multiply_xx_0, '0', blocks_complex_to_arg_0, '0']
- [filter_fft_low_pass_filter_0, '0', blocks_delay_0, '0']
- [filter_fft_low_pass_filter_0, '0', blocks_multiply_xx_0, '0']
- [filter_fft_low_pass_filter_1, '0', analog_fm_deemph_0, '0']
- [rtlsdr_source_0, '0', filter_fft_low_pass_filter_0, '0']
- [rtlsdr_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
