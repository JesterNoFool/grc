options:
  parameters:
    author: Gary Schafer
    generate_options: qt_gui
    id: polyphase_bpf
    output_language: python
    title: Polyphase Bandpass Filter
  states: {}

blocks:
- name: channel
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,0,1,20
    label: Channel
    start: '0'
    step: '1'
    stop: '10'
    value: '0'
  states: {}
- name: dec
  id: variable
  parameters:
    value: '12'
  states: {}
- name: numZeros
  id: variable
  parameters:
    value: dec-np.mod(protoLength,dec)
  states: {}
- name: padLength
  id: variable
  parameters:
    value: len(padTaps)
  states: {}
- name: padTaps
  id: variable
  parameters:
    value: '[*protoTaps,*zeropad]'
  states: {}
- name: protoLength
  id: variable
  parameters:
    value: len(protoTaps)
  states: {}
- name: protoTaps
  id: variable_band_pass_filter_taps
  parameters:
    gain: '1.0'
    high_cutoff_freq: (-1e6+(channel*200e3))+90e3
    low_cutoff_freq: (-1e6+(channel*200e3))-90e3
    samp_rate: samp_rate
    type: complex_band_pass
    width: 10e3
    win: window.WIN_HAMMING
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.4e6
  states: {}
- name: zeropad
  id: variable
  parameters:
    value: '[0,]*numZeros'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: samp_rate/12/(2*math.pi*85e3)
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: dec
    type: complex
  states: {}
- name: blocks_stream_demux_0
  id: blocks_stream_demux
  parameters:
    lengths: (1,)*dec
    num_outputs: dec
    type: complex
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: padTaps[11:padLength:dec]
    type: ccc
  states: {}
- name: fir_filter_xxx_0_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: padTaps[10:padLength:dec]
    type: ccc
  states: {}
- name: fir_filter_xxx_0_0_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: padTaps[8:padLength:dec]
    type: ccc
  states: {}
- name: fir_filter_xxx_0_0_0_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: padTaps[4:padLength:dec]
    type: ccc
  states: {}
- name: fir_filter_xxx_0_0_0_1
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: padTaps[0:padLength:dec]
    type: ccc
  states: {}
- name: fir_filter_xxx_0_0_1
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: padTaps[6:padLength:dec]
    type: ccc
  states: {}
- name: fir_filter_xxx_0_0_2
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: padTaps[2:padLength:dec]
    type: ccc
  states: {}
- name: fir_filter_xxx_0_1
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: padTaps[9:padLength:dec]
    type: ccc
  states: {}
- name: fir_filter_xxx_0_1_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: padTaps[5:padLength:dec]
    type: ccc
  states: {}
- name: fir_filter_xxx_0_1_1
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: padTaps[1:padLength:dec]
    type: ccc
  states: {}
- name: fir_filter_xxx_0_2
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: padTaps[7:padLength:dec]
    type: ccc
  states: {}
- name: fir_filter_xxx_0_3
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: padTaps[3:padLength:dec]
    type: ccc
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: myTabs
  id: qtgui_tab_widget
  parameters:
    gui_hint: 1,0,20,20
    label0: Full Spectrum
    label1: Filtered Spectrum
    label2: Baseband (Demod) Spectrum
    num_tabs: '3'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/dec
    color1: '"black"'
    fc: '0'
    fftsize: '2048'
    freqhalf: 'False'
    grid: 'True'
    gui_hint: myTabs@2
    legend: 'False'
    name: Baseband Spectrum
    type: float
    update_time: '0.01'
    ymax: '-20'
    ymin: '-120'
  states: {}
- name: qtgui_freq_sink_x_1
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    color1: '"black"'
    fc: '0'
    fftsize: '8192'
    grid: 'True'
    gui_hint: myTabs@0
    legend: 'False'
    name: RF Spectrum
    type: complex
    update_time: '0.01'
    ymax: '-20'
    ymin: '-120'
  states: {}
- name: qtgui_freq_sink_x_2
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    color1: '"black"'
    fc: '0'
    fftsize: '2048'
    grid: 'True'
    gui_hint: myTabs@1
    legend: 'False'
    name: Filtered Spectrum
    type: complex
    update_time: '0.01'
    ymax: '-20'
    ymin: '-120'
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: 91.9e6
    gain0: '18'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_add_xx_0, '0', analog_quadrature_demod_cf_0, '0']
- [blocks_add_xx_0, '0', qtgui_freq_sink_x_2, '0']
- [blocks_stream_demux_0, '0', fir_filter_xxx_0, '0']
- [blocks_stream_demux_0, '1', fir_filter_xxx_0_0, '0']
- [blocks_stream_demux_0, '10', fir_filter_xxx_0_1_1, '0']
- [blocks_stream_demux_0, '11', fir_filter_xxx_0_0_0_1, '0']
- [blocks_stream_demux_0, '2', fir_filter_xxx_0_1, '0']
- [blocks_stream_demux_0, '3', fir_filter_xxx_0_0_0, '0']
- [blocks_stream_demux_0, '4', fir_filter_xxx_0_2, '0']
- [blocks_stream_demux_0, '5', fir_filter_xxx_0_0_1, '0']
- [blocks_stream_demux_0, '6', fir_filter_xxx_0_1_0, '0']
- [blocks_stream_demux_0, '7', fir_filter_xxx_0_0_0_0, '0']
- [blocks_stream_demux_0, '8', fir_filter_xxx_0_3, '0']
- [blocks_stream_demux_0, '9', fir_filter_xxx_0_0_2, '0']
- [fir_filter_xxx_0, '0', blocks_add_xx_0, '0']
- [fir_filter_xxx_0_0, '0', blocks_add_xx_0, '1']
- [fir_filter_xxx_0_0_0, '0', blocks_add_xx_0, '3']
- [fir_filter_xxx_0_0_0_0, '0', blocks_add_xx_0, '7']
- [fir_filter_xxx_0_0_0_1, '0', blocks_add_xx_0, '11']
- [fir_filter_xxx_0_0_1, '0', blocks_add_xx_0, '5']
- [fir_filter_xxx_0_0_2, '0', blocks_add_xx_0, '9']
- [fir_filter_xxx_0_1, '0', blocks_add_xx_0, '2']
- [fir_filter_xxx_0_1_0, '0', blocks_add_xx_0, '6']
- [fir_filter_xxx_0_1_1, '0', blocks_add_xx_0, '10']
- [fir_filter_xxx_0_2, '0', blocks_add_xx_0, '4']
- [fir_filter_xxx_0_3, '0', blocks_add_xx_0, '8']
- [rtlsdr_source_0, '0', blocks_stream_demux_0, '0']
- [rtlsdr_source_0, '0', qtgui_freq_sink_x_1, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
